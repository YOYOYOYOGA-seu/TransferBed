# Keil uVision project ElectricTransferBed.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: ElectricTransferBed
  c flags: OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\lib\header;.\lib\FatFs\source
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Source
    ./: main.c
    ./lib/source/: bmp.c delay.c KEY.c lcd.c LED.c NVIC.c flash.c rtc.c stm32f10x_it.c TIM.c touch_screen.c sdio_sdcard.c sd_operate.c motor_control.c limit_switch.c trans_bed.cpp
    ./lib/source_CPP/: interface.cpp
  group head
    ./lib/header/: ascii.h bmp.h common.h lcd.h delay.h flash.h key.h led.h nvic.h rtc.h stm32f10x_it.h tim.h touch_screen.h sd_operate.h sdio_sdcard.h limit_switch.h motor_control.h interface.h trans_bed.h class_definition.h
  group FatFs
    ./lib/FatFs/source/: diskio.c diskio.h ff.c ff.h ffconf.h ffsystem.c ffunicode.c integer.h
software components: CMSIS:CORE 5.1.1, Device:Startup 1.0.0, Device:StdPeriph Drivers:BKP 3.5.0, Device:StdPeriph Drivers:DMA 3.5.0, Device:StdPeriph Drivers:EXTI 3.5.0, Device:StdPeriph Drivers:FSMC 3.5.0, Device:StdPeriph Drivers:Flash 3.5.0, Device:StdPeriph Drivers:Framework 3.5.1, Device:StdPeriph Drivers:GPIO 3.5.0, Device:StdPeriph Drivers:PWR 3.5.0, Device:StdPeriph Drivers:RCC 3.5.0, Device:StdPeriph Drivers:RTC 3.5.0, Device:StdPeriph Drivers:SDIO 3.5.0, Device:StdPeriph Drivers:SPI 3.5.0, Device:StdPeriph Drivers:TIM 3.5.0, Device:StdPeriph Drivers:USART 3.5.0
